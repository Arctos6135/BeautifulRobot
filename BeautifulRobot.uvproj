# Keil uVision project BeautifulRobot.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C2052AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: BeautifulRobot +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: main.c delay.c ws2812b.c delay.h ws2812b.h uart.c uart.h
